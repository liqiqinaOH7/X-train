# Keil uVision project RTC.uvprojx, settings and files
target RTC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\USMART;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\READ;..\HARDWARE\Train_Display;..\HARDWARE\Time_Display;..\HARDWARE\Train_Set;..\HARDWARE\KEY;..\HARDWARE\24cxx;..\HARDWARE\CTIIC;..\HARDWARE\FT5206;..\HARDWARE\GT9147;..\HARDWARE\myiic;..\HARDWARE\OTT2001A;..\HARDWARE\TOUCH;..\HARDWARE\COVER;..\HARDWARE\TIMER;..\HARDWARE\Speed
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c getnowspeed.s
  group CORE
    ../CORE/: core_cm3.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RTC/: rtc.c
    ./: pic.h gpio.c gpio.h
    ../HARDWARE/READ/: read.c read.h
    ../HARDWARE/Train_Display/: train_display.c train_display.h
    ../HARDWARE/Time_Display/: time_display.c time_display.h
    ../HARDWARE/Train_Set/: train_set.c train_set.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/24cxx/: 24cxx.c 24cxx.h
    ../HARDWARE/CTIIC/: ctiic.c ctiic.h
    ../HARDWARE/FT5206/: ft5206.c ft5206.h
    ../HARDWARE/GT9147/: gt9147.c gt9147.h
    ../HARDWARE/myiic/: myiic.c myiic.h
    ../HARDWARE/OTT2001A/: ott2001a.c ott2001a.h
    ../HARDWARE/TOUCH/: touch.c touch.h
    ../HARDWARE/read_signal/: read_siganl2.c read_signal2.h
    ../HARDWARE/COVER/: cover.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/Speed/: speed.c speed.h
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
